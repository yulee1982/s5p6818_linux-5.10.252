/*
 * Copyright (C) 2016  Nexell Co., Ltd.
 * Author: Youngbok, Park <ybpark@nexell.co.kr>
 *
 * This program is free software; you can redistribute it and/or
 * modify it under the terms of the GNU General Public License
 * as published by the Free Software Foundation; either version 2
 * of the License, or (at your option) any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

/dts-v1/;
#include <dt-bindings/interrupt-controller/irq.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/thermal/thermal.h>
#include "s5p6818.dtsi"

#define PMIC_PDATA_INIT(_id, _rname, _minuv,	\
			_maxuv, _always_on, _boot_on,		\
			_init_uv, _init_enable, _slp_slots)	\
		regulator-name = _rname;		\
		regulator-min-microvolt = <_minuv>;	\
		regulator-max-microvolt = <_maxuv>;	\
		nx,id = <_id>;				\
		nx,always_on = <_always_on>;		\
		nx,boot_on = <_boot_on>;		\
		nx,init_enable = <_init_enable>;	\
		nx,init_uV = <_init_uv>;		\
		nx,sleep_slots = <_slp_slots>;

/ {
	model = "FriendlyElec NanoPC-T3";
	compatible = "friendlyelec,nanopc-t3", "nexell,s5p6818";

	chosen {
		/*bootargs = "console=tty0 console=ttySAC0,115200n8 earlycon=s5p6818,0xc00a1000";*/
		bootargs = "console=tty0 console=ttySAC0,115200n8 rdinit=/init";
		stdout-path = "serial0:115200n8";
	};

	memory@40000000 {
		device_type = "memory";
		reg = <0x40000000 0x7db00000>;
	};

	mach: board {
		compatible = "friendlyelec,board";
		machine = "NANOPCT3";
		hwrev = <1>;
		model = "NanoPC T3 Series";
	};
};

&soc {

	aliases {
		ethernet0 = &gmac0;
	};

	/* FIXME: bluetooth reset is piggybacked here although their data flow
	* goes through serial1 */
	wifi_powerseq: wifi_powerseq  {
		compatible = "mmc-pwrseq-simple";
		reset-gpios = <&gpio_b 24 GPIO_ACTIVE_LOW		/* wifi */
				&gpio_b 8 GPIO_ACTIVE_LOW>;		/* bluetooth */
		post-power-on-delay-ms = <50>;
	};

	i2c3_gpio:i2c@0 {
		compatible = "i2c-gpio";
		gpios = <&gpio_e 31 0	/* sda */
			&gpio_e 30 0	/* scl */
			>;
		i2c-gpio,delay-us = <10>;/* ~100 kHz */
		i2c-gpio,ch =<3>;

		#address-cells = <1>;
		#size-cells = <0>;

		axp228@34 {
			compatible = "x-powers,axp228";
			reg = <0x34>;
			interrupt-parent = <&alive_0>;	// CFG_GPIO_PMIC_INTR
			interrupts = <0x4 IRQ_TYPE_EDGE_FALLING>;
			nx,id = <0>;
			/* vdd_arm-supply = <&VCC1P1_ARM_PMIC>; */
			/* vdd_core-supply = <&VCC1P0_CORE_PMIC>; */
			regulators {
				VCC_LDO1:
					axp22_rtcldo{PMIC_PDATA_INIT(0,
					"axp228_rtcldo",
					3000000, 3000000, 0, 0, 3300000,
					0, 0xF) };
				VCC_LDO2:
					axp22_aldo1{PMIC_PDATA_INIT(1,
					"axp228_3p3_alive",
					700000, 3300000, 1, 1, 3300000,
					1, 0xF) };
				VCC_LDO3:
					axp22_aldo2{PMIC_PDATA_INIT(2,
					"axp228_1p8_alive",
					700000, 3300000, 1, 1, 1800000,
					1, 0xF) };
				VCC_LDO4:
					axp22_aldo3{PMIC_PDATA_INIT(3,
					"axp228_1p0_alive",
					700000, 3300000, 1, 1, 1000000,
					1, 0xF) };
				VCC_LDO5:
					axp22_dldo1{PMIC_PDATA_INIT(4,
					"axp228_wide",
					700000, 3300000, 1, 1, 3300000,
					1, 0xF) };
				VCC_LDO6:
					axp22_dldo2{PMIC_PDATA_INIT(5,
					"axp228_1p8_cam",
					700000, 3300000, 0, 0, 1800000,
					0, 0xF) };
				VCC_LDO7:
					axp22_dldo3{PMIC_PDATA_INIT(6,
					"axp228_dldo3",
					700000, 3300000, 0, 0,  700000,
					0, 0xF) };
				VCC_LDO8:
					axp22_dldo4{PMIC_PDATA_INIT(7,
					"axp228_dldo4",
					700000, 3300000, 0, 0,  700000,
					0, 0xF) };
				VCC_LDO9:
					axp22_eldo1{PMIC_PDATA_INIT(8,
					"axp228_1p8_sys",
					700000, 3300000, 1, 1, 1800000,
					1, 0xF) };
				VCC_LDO10:
					axp22_eldo2{PMIC_PDATA_INIT(9,
					"axp228_3p3_wifi",
					700000, 3300000, 1, 1, 3300000,
					1, 0xF) };
				VCC_LDO11:
					axp22_eldo3{PMIC_PDATA_INIT(10,
					"axp228_eldo3",
					700000, 3300000, 0, 0,  700000,
					0, 0xF) };
				VCC_LDO12:
					axp22_dc5ldo{PMIC_PDATA_INIT(11,
					"axp228_1p2_cvbs",
					700000, 1400000, 0, 0, 1200000,
					0, 0xF) };
				VCC_DCDC1:
					axp22_dcdc1{PMIC_PDATA_INIT(12,
					"axp228_3p3_sys",
					1600000, 3400000, 1, 1, 3300000,
					1, 0xF) };
				VCC1P1_ARM_PMIC:
					axp22_dcdc2{PMIC_PDATA_INIT(13,
					"axp228_1p1_arm",
					600000, 1540000, 1, 1, 1200000,
					1, 0xF) };
				VCC1P0_CORE_PMIC:
					axp22_dcdc3{PMIC_PDATA_INIT(14,
					"axp228_1p0_core",
					600000, 1860000, 1, 1, 1200000,
					1, 0xF) };
				VCC_DCDC4:
					axp22_dcdc4{PMIC_PDATA_INIT(15,
					"axp228_1p5_sys",
					600000, 1540000, 1, 1, 1500000,
					1, 0xF) };
				VCC_DCDC5:
					axp22_dcdc5{PMIC_PDATA_INIT(16,
					"axp228_1p5_ddr",
					1000000, 2550000, 1, 1, 1500000,
					1, 0xF) };
				VCC_LDOIO0:
					axp22_ldoio0{PMIC_PDATA_INIT(17,
					"axp228_ldoio0",
					700000, 3300000, 0, 0, 1800000,
					0, 0xF) };
				VCC_LDOIO1:
					axp22_ldoio1{PMIC_PDATA_INIT(18,
					"axp228_ldoio1",
					700000, 3300000, 0, 0, 1000000,
					0, 0xF) };
			};
		};
	};

	nanopi-thermistor {
		compatible = "friendlyarm,nanopi-thermistor";
		status = "okay";

		io-channels = <&adc 2>;
		io-channel-names = "nanopi-thermistor";
	};

	leds: gpio-leds {
		compatible = "gpio-leds";
		pinctrl-names = "default";
		pinctrl-0 =<&led1_gpio>;

		led@1 {
			gpios = <&gpio_b 12 GPIO_ACTIVE_LOW>;
			label = "status_led";
			linux,default-trigger = "heartbeat";
			linux,default-trigger-delay-ms = <0>;
		};
	};
};

&uart0 {
	clock-frequency = <147500000>;
};
&uart1 {
	clock-frequency = <147500000>;
};
&uart2 {
	clock-frequency = <147500000>;
};
&uart3 {
	clock-frequency = <147500000>;
};
&uart4 {
	clock-frequency = <147500000>;
};
&uart5 {
	clock-frequency = <147500000>;
};
&pwm0 {
	clock-frequency = <100000000>;
};
&i2c0 {
	clock-frequency = <200000000>;
};
&i2c1  {
	clock-frequency = <200000000>;
};
&i2c2  {
	clock-frequency = <200000000>;
};
&vip1 {
	src-force = <4>;
};

&serial0 {
	status ="okay";
};
&serial1 {
	status ="okay";
	pinctrl-names = "default";
	pinctrl-0 = <&serial1_pin &serial1_flow>;
};
&pl08xdma0 {
	use_isr;
	ch12 {
		slave_wait_flush_dma;
	};
	ch13 {
		slave_wait_flush_dma;
	};
	ch14 {
		slave_wait_flush_dma;
	};
	ch15 {
		slave_wait_flush_dma;
	};
};
&pl08xdma1 {
	use_isr;
	ch0 {
		slave_wait_flush_dma;
	};
	ch1 {
		slave_wait_flush_dma;
	};
};
&pinctrl_0 {
	led1_gpio: leds-gpio {
		nexell,pins ="gpiob-12";
		nexell,pin-function = <2>;
		nexell,pin-pull = <2>;
		nexell,pin-strength = <0>;
	};
};
&dw_mmc_0 {	// mappings from kernel 3.x:
	num-slots = <1>;
	bus-width = <4>;		// MMC_CAP_4_BIT_DATA
	cap-sd-highspeed;		// DW_MCI_QUIRK_HIGHSPEED
	cap-mmc-highspeed;		// also DW_MCI_QUIRK_HIGHSPEED
	clock-frequency = <100000000>;	// bus_hz: 100 * 1000 * 1000
	card-detect-delay = <200>;	// detect_delay_ms
	disable-wp;		        // write protect: -> get_ro; not use for micro SD
	cd-gpios = <&alive_0 1 0>;      //卡检测 <&alive_0 1 GPIO_ACTIVE_LOW>
	// card detect: CFG_SDMMC0_DETECT_IO == PAD_GPIO_ALV + 1
	cd-inverted;                    // CD line is active high
	nexell,drive_dly = <0x0>;	// DW_MMC_DRIVE_DELAY(0)
	nexell,drive_shift = <0x02>;	// DW_MMC_DRIVE_PHASE(2)
	nexell,sample_dly = <0x00>;	// DW_MMC_SAMPLE_DELAY(0)
	nexell,sample_shift = <0x01>;	// DW_MMC_SAMPLE_PHASE(1)
	status = "okay";
};
&dw_mmc_1 {
	bus-width = <4>;
	cap-sd-highspeed;
	clock-frequency = <100000000>;
	card-detect-delay = <200>;
	non-removable;
	keep-power-in-suspend;
	nexell,drive_dly = <0x0>;
	nexell,drive_shift = <0x02>;
	nexell,sample_dly = <0x00>;
	nexell,sample_shift = <0x01>;
	mmc-pwrseq = <&wifi_powerseq>;
	status = "okay";

	/* wifi definition for brcmfmac.ko module */
	brcmf: bcrmf@1 {
		compatible = "brcm,bcm4329-fmac";
		reg = <1>;
		interrupt-parent = <&gpio_c>;
		interrupts = <17 IRQ_TYPE_LEVEL_HIGH>;
		brcm,powersave-default-off;
	};
};
&dw_mmc_2 {
	bus-width = <4>;		// MMC_CAP_4_BIT_DATA
	cap-sd-highspeed;		// DW_MCI_QUIRK_HIGHSPEED
	cap-mmc-highspeed;		// also DW_MCI_QUIRK_HIGHSPEED
	//sd-uhs-ddr50;			// MMC_CAP_UHS_DDR50
	//cap-mmc-hw-reset;		// MMC_CAP_HW_RESET
	clock-frequency = <200000000>;	// bus_hz: 200 * 1000 * 1000
	card-detect-delay = <200>;	// detect_delay_ms
	non-removable;			// MMC_CAP_NONREMOVABLE
	broken-cd;
	//cd-gpios = <&gpio_c 24 GPIO_ACTIVE_LOW>;
	disable-wp;
	nexell,drive_dly = <0x0>;	// DW_MMC_DRIVE_DELAY(0)
	nexell,drive_shift = <0x03>;	// DW_MMC_DRIVE_PHASE(3)
	nexell,sample_dly = <0x00>;	// DW_MMC_SAMPLE_DELAY(0)
	nexell,sample_shift = <0x02>;	// DW_MMC_SAMPLE_PHASE(2)
	status = "okay";
};
&nexell_usbphy {
	status = "okay";
};
&ehci {
	status = "okay";
	port@0 {
		status = "okay";
	};
};
&ohci {
	status = "okay";
	port@0 {
		status = "okay";
	};
};
&i2c_0 {
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";

	es8316_codec: es8316@11 {
		#sound-dai-cells = <0>;
		compatible = "everest,es8316";
		reg = <0x11>;
	};
};
&i2c_1 {
	status = "okay";
};
&i2c_2 {
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";

	/* Note: touch sensors are registered by onewire */
	/*touchscreen@38 {
		compatible = "edt,edt-ft5506";
		reg = <0x38>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_EDGE_FALLING>;
		pinctrl-names = "default";
		pinctrl-0 = <&touchpanel_irq>;
		touchscreen-size-x = <1280>;
		touchscreen-size-y = <800>;
		touchscreen-max-pressure = <255>;
	};*/

	/*touchscreen@46 {
		compatible = "ite,it7260";
		reg = <0x46>;
		interrupt-parent = <&gpio_c>;
		interrupts = <16 IRQ_TYPE_LEVEL_LOW>;
		pinctrl-names = "default";
		pinctrl-0 = <&touchpanel_irq>;
	};*/
};
&pwm {
	// block pwm3_pin - conflicts with spi0_miso (on spi0_bus) drawn on 2.54mm header
	pinctrl-0 = <&pwm0_pin &pwm1_pin &pwm2_pin>;
	samsung,pwm-outputs = <0>, <1>, <2>;
	status = "okay";
};
&vip_1 {
	status = "okay";
};
&clipper_1 {
	status = "okay";
	pwms = <&pwm 1 41 0>; /* 1000000000/41 */
	interface_type = <NX_CAPTURE_INTERFACE_PARALLEL>;
	pinctrl-names = "default";
	pinctrl-0 = <&vid1_data_clk &vid1_sync> ;
	port = <0>;
	external_sync = <0>;
	data_order = <NX_VIN_Y0CBY1CR>;
	interlace = <0>;
	regulator_names = "axp22_dldo2";
	regulator_voltages = <1800000>;

	gpios = <&gpio_c 4 0
		 &gpio_c 5 0
		 &gpio_c 6 0>;

	sensor {
		type = <NX_CAPTURE_SENSOR_I2C>;
		i2c_name = "SP2518";
		i2c_adapter = <0>;
		addr = <0x30>;
	};

	power {
		enable_seq = <
		NX_ACTION_START NX_ACTION_TYPE_GPIO 2 1 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_PMIC 0 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_PMIC 1 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 0 0 0 1 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_CLOCK 1 10 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 0 0 0 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 1 1 0 0 1 NX_ACTION_END
		NX_ACTION_START NX_ACTION_TYPE_GPIO 1 1 100 NX_ACTION_END
		>;
	};
};
&rtc {
	status = "okay";
};
&tmuctrl_0 {
	status = "okay";
};
&i2s_0 {
	#sound-dai-cells = <1>;
	sample-rate = <48000>;
	frame-bit = <32>;
	status = "okay";
};
&spdif_tx {
	#sound-dai-cells = <1>;
	status = "okay";
};
&adc {
	status = "okay";
};
&scaler {
	status = "okay";
};
